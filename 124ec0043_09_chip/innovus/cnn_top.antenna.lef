

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO cnn_top 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.7332 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2994 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.0744 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8636 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 5.53162 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 26.9308 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.484615 LAYER Via4 ;
  END clk
  PIN rst_n 
    ANTENNAPARTIALMETALAREA 1.2428 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5926 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 80.1883 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 367.444 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.79938 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.9648 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.928 LAYER Metal4 ;
    ANTENNAGATEAREA 0.56205 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 83.684 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 383.329 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.77741 LAYER Via4 ;
  END rst_n
  PIN start_i 
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2232 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0332 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.6904 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.6356 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 103.283 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 475.446 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 8.88291 LAYER Via5 ;
  END start_i
  PIN pixel_i[7] 
  END pixel_i[7]
  PIN pixel_i[6] 
  END pixel_i[6]
  PIN pixel_i[5] 
  END pixel_i[5]
  PIN pixel_i[4] 
  END pixel_i[4]
  PIN pixel_i[3] 
  END pixel_i[3]
  PIN pixel_i[2] 
  END pixel_i[2]
  PIN pixel_i[1] 
  END pixel_i[1]
  PIN pixel_i[0] 
  END pixel_i[0]
  PIN load_o 
    ANTENNADIFFAREA 1.7432 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.318 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9598 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.19125 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.6903 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 136.778 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 12.1793 LAYER Via3 ;
  END load_o
  PIN pixel_idx_o[9] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.7164 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2238 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.30555 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.0805 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 80.9283 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.43102 LAYER Via3 ;
  END pixel_idx_o[9]
  PIN pixel_idx_o[8] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.7332 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2994 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3348 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.0117 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 77.6391 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.42408 LAYER Via3 ;
  END pixel_idx_o[8]
  PIN pixel_idx_o[7] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0348 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6566 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.30555 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.801 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 85.691 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNAMAXCUTCAR 8.44012 LAYER Via3 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.2536 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.17 LAYER Metal4 ;
    ANTENNAGATEAREA 0.32175 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.5892 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 89.3274 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.44012 LAYER Via4 ;
  END pixel_idx_o[7]
  PIN pixel_idx_o[6] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.3804 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2406 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3348 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.5913 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 84.8334 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.42408 LAYER Via3 ;
  END pixel_idx_o[6]
  PIN pixel_idx_o[5] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2932 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8194 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3348 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.3309 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 83.5754 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.42408 LAYER Via3 ;
  END pixel_idx_o[5]
  PIN pixel_idx_o[4] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.3396 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0282 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3348 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.4937 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 84.3082 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.42408 LAYER Via3 ;
  END pixel_idx_o[4]
  PIN pixel_idx_o[3] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1956 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3802 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3348 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.5702 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 82.669 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.42408 LAYER Via3 ;
  END pixel_idx_o[3]
  PIN pixel_idx_o[2] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.7428 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3714 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3348 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.834 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 81.4253 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.42408 LAYER Via3 ;
  END pixel_idx_o[2]
  PIN pixel_idx_o[1] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9004 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0806 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.1071 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 81.51 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.43102 LAYER Via3 ;
  END pixel_idx_o[1]
  PIN pixel_idx_o[0] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0956 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.959 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3348 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.8126 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 81.1406 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.43102 LAYER Via3 ;
  END pixel_idx_o[0]
  PIN busy_o 
    ANTENNADIFFAREA 1.7432 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1148 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0166 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1782 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.6689 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 136.542 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 12.1812 LAYER Via3 ;
  END busy_o
  PIN done_o 
    ANTENNADIFFAREA 1.7432 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9724 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3758 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.2494 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 125.67 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 12.184 LAYER Via3 ;
  END done_o
  PIN prediction_o[3] 
    ANTENNADIFFAREA 0.1448 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5012 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2842 LAYER Metal3 ;
  END prediction_o[3]
  PIN prediction_o[2] 
    ANTENNADIFFAREA 0.1448 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.4372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9962 LAYER Metal3 ;
  END prediction_o[2]
  PIN prediction_o[1] 
    ANTENNADIFFAREA 0.1448 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5316 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.421 LAYER Metal3 ;
  END prediction_o[1]
  PIN prediction_o[0] 
    ANTENNADIFFAREA 0.1448 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5644 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5686 LAYER Metal3 ;
  END prediction_o[0]
END cnn_top

END LIBRARY
